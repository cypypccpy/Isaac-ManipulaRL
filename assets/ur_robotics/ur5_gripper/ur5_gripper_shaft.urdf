Commit message: add convex demo

File: assets/ur_robotics/ur5_gripper/ur5_gripper_shaft.urdf (robot description, URDF)
Before this commit: robot ur5, 22 links, 21 joints
Joints:
- joint shaft_joint: origin xyz=-0.0 0.26 -0.06 rpy=1.57 1.57 0.0 -> xyz=-0.0 0.26 0.00 rpy=1.57 1.57 0.0
